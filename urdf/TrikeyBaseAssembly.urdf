Commit message: Got rid of dummy link and dummy join

File: urdf/TrikeyBaseAssembly.urdf (robot description, URDF)
Before this commit: robot trikey, 10 links, 9 joints
Links:
- removed link dummy
Joints:
- removed joint dummy_joint
